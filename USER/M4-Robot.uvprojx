# Keil uVision project M4-Robot.uvprojx, settings and files
target M4-Robot (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: M4-Robot +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,__FPU_PRESENT=1,__FPU_USED =1,ARM_MATH_CM4,__CC_ARM
  c include: ..\USER;..\STM32F4xx_FWLib\inc;..\CMSIS;.\MotorLib;.\MotorLib\inc;.\Driver\inc;.\Value\inc;.\RobotCAN_Lib\inc;.\RobotCAN_Lib;..\UCOS3\uC-CPU;..\UCOS3\uC-LIB;..\UCOS3\uC-LIB\Ports;..\UCOS3\uCOS-III\Ports;..\UCOS3\uCOS-III\Source;..\TASK;..\rtt\RTT;.\Com_Lib;.\TEST\ins;.\hust_utils_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: includes.h os_app_hooks.c main.c stm32f4xx_it.c system_config.c stm32f4xx_conf.h delay.c globalTime.c
  group Task
    ../TASK/: task_init.c task_init.h task_handle.c
    ./: system_config.h task_sensor.c task_list.c task_move.c
  group Value
    ./Value/inc/: MyType.h
    ./Value/src/: MyGlobe.c
  group Can_Lib
    ./RobotCAN_Lib/src/: RobotCAN_basic.c RobotCAN_CommandLib.c RobotCAN_ExecuteLib.c RobotCAN_proplist.c
    ./RobotCAN_Lib/inc/: RobotCAN_IDconf.h
  group Driver
    ./Driver/src/: LED.c USART.c CAN.c Encoder.c EXT_IO.c Switch.c ZY_VisualScope.c VESC_CAN.c spi.c AS5047P.c ADXRS453.c Elmo.c TIM.c IIC.c LED_WS2815b.c
  group uC/CPU
    ../UCOS3/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../UCOS3/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOS3/uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS3_Source
    ../UCOS3/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS3_Port
    ../UCOS3/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group STM32F4xx_FWLib
    ../STM32F4xx_FWLib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group StartCode
    ../CMSIS/: startup_stm32f4xx.s
  group ComLib
    ./Com_Lib/: RobotCOM_basic.c RobotCOM_CommandLib.c RobotCOM_ExecuteLib.c RobotCOM_proplist.c
  group MotorLib
    ./MotorLib/src/: motor_control.c
  group TEST
    ./TEST/src/: TurnArrow.c HoldGrip.c Archery.c
    ./hust_utils_lib/: hust_math_lib.c
software components: CMSIS:CORE 5.5.0
